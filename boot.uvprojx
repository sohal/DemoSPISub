# Keil uVision project boot.uvprojx, settings and files
target STM32F0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F042G6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SELECT_TORQUE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group BSP
    ./: BSP.c Flash.c CRC.c Usart1.c CAN.c
  group Protocol
    ./: ProtoStateMachine.c
  group main
    ./: main.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.2.3
